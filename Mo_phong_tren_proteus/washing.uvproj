# Keil uVision project washing.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: washing +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    C:/Users/Admin/Downloads/Compressed/washing-machine-8051-master/: Delay.c Delay.h Main.c Main.h Port.h Seven_segment.c Seven_segment.h SOES.c SOES.h Switch.c Switch.h Washer.c Washer.h
